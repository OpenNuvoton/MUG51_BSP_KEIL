# Keil uVision project Project_temp.uvproj, settings and files
target Target1 (MCS-51)
  device: MUG51TB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Project_temp +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: HelloWorld.c
  group Library
    ../../../../Library/StdDriver/src/: sys.c acmp.c capture.c eeprom.c exint.c gpio.c i2c.c IAP.c pdma.c pinint.c putchar.c uart.c wdt.c wkt.c delay.c common.c eeprom_sprom.c lowpwer.c power.c pwm0.c uart2.c timer.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
