# Keil uVision project GPIO_autoReturn.uvproj, settings and files
target Regbased (MCS-51)
  device: MUG51TB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: GPIO_autoReturn +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: GPIO_RT.C
  group Common
    ../../../../Library/StdDriver/src/: common.c gpio.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUPQUICK.A51
