# Keil uVision project SPROM.uvproj, settings and files
target RegBased (MCS-51)
  device: ML51MD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: SPROM +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex 0x0 0x1200 0xFF80 0x80
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: main.C SPROM.C ProtectBit.C
  group Common
    ../../../../Library/StdDriver/src/: uart.c delay.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
