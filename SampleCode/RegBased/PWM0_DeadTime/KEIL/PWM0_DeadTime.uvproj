# Keil uVision project PWM0_DeadTime.uvproj, settings and files
target Regbased (MCS-51)
  device: MUG51TB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: PWM0_DT +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: PWM0_DT.C
  group Common
    ../../../../Library/StdDriver/src/: Delay.c common.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
