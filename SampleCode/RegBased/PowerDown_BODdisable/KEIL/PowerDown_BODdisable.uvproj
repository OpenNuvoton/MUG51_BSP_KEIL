# Keil uVision project PowerDown_BODdisable.uvproj, settings and files
target Regbased (MCS-51)
  device: MUG51TB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: PowerDown_BODdisable +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: PD_BODdis.C
  group Common
    ../../../../Library/StdDriver/src/: delay.c common.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
