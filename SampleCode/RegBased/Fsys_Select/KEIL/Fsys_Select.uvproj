# Keil uVision project Fsys_Select.uvproj, settings and files
target Regbased (MCS-51)
  device: MUG51TB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Fsys_Select +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: Fsys_SEL.c
  group Common
    ../../../../Library/StdDriver/src/: common.c sys.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
