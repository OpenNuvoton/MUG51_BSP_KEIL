# Keil uVision project LIBROM_PD_Delay.uvproj, settings and files
target StdDriver (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: LIBROM_PD_Delay +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: LIBROM_application.C
  group Library
    ../../../../Library/StdDriver/src/: common.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
  group LIBROM
    ../../../../Library/StdDriver/src/: librom.c
