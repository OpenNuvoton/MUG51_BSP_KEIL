# Keil uVision project Timer2_ACMP.uvproj, settings and files
target Target 1 (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: Timer2_ACMP +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: Timer2_ACMP.c
  group Common
    ../../../../Library/StdDriver/src/: common.c capture.c acmp.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
