# Keil uVision project GPIO_Input_Output.uvproj, settings and files
target Regbased (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: GPIO_Input_Output +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: GPIO.C
  group Common
    ../../../../Library/StdDriver/src/: delay.c capture.c uart.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
