# Keil uVision project ISP_UART0_1wire_P30.uvproj, settings and files
target RegBased (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: MS51_UART0_ISP +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: ISP_UART0_main_autosize.c isp_uart0_1wire_p30.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
