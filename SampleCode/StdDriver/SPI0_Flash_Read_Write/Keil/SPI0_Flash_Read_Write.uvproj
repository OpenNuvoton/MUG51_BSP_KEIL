# Keil uVision project SPI0_Flash_Read_Write.uvproj, settings and files
target StdDriver (MCS-51)
  device: MUG51TB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x7FFF)  XRAM(0 - 0x7FF) CLOCK(24000000)
  output: SPI0_Flash_Read_Write +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source
    ../: SPI0_Flash_RW.c
  group Library
    ../../../../Library/StdDriver/src/: common.c spi.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
