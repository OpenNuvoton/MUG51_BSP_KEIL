# Keil uVision project GPIO_Pull_UpDown.uvproj, settings and files
target StdDriver (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: GPIO_Pull_UpDown +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  group Source Group 1
    ../: GPIO_Pull_UpDown.c
  group Library
    ../../../../Library/StdDriver/src/: common.c gpio.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
