# Keil uVision project GPIO_Pin_Interrupt.uvproj, settings and files
target StdDriver (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: GPIO_Pin_Interrupt +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: Pin_Int_LIB.C
  group Common
    ../../../../Library/StdDriver/src/: common.c uart.c pinint.c gpio.c
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
