# Keil uVision project LIBROM_PD_Delay.uvproj, settings and files
target StdDriver (MCS-51)
  device: MUG51TB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: LIBROM_PD_Delay +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\Common;..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: LIBROM_Delay.C
  group Startup
    ../../../../Library/Startup/KEIL/: STARTUP.A51
  group Common
    ../../../../Library/StdDriver/src/: common.c
    ../../../../Library/LIBROM/src/: LIBROM_lib.c
