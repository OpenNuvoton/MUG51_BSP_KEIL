# Keil uVision project GPIO_INV.uvproj, settings and files
target Regbased (MCS-51)
  device: ML56SD1AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM(0 - 0xFFF) CLOCK(24000000)
  output: GPIO +hex
  AfterMake: $K\C51\NULink\Hex2Bin.exe .\output\@L.hex
  c flags: Optimize=4 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc
  link misc: REMOVEUNUSED
  group Source Group 1
    ../: GPIO_INV.C
  group Common
    ../../../../Library/StdDriver/src/: common.c Delay.c
  group Startup
    ../../../../../../../0.HAG037_ML56_ML54_ML51_64K/BSP_ALL/ML56_BSP_Keil_C51_FULL/Library/Startup/KEIL/: STARTUPQUICK.A51
